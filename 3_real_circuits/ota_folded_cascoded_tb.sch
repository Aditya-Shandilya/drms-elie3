** sch_path: 3_real_circuits/ota_folded_cascoded_tb.sch
**.subckt ota_folded_cascoded_tb
VCM vcm_ref GND {Vcm}
VinP inp GND PULSE(1.2 1.2005 1u 1n 1n 5u 10u) DC 1.2 AC 0.5m
VinN inn GND PULSE(1.2 1.1995 1u 1n 1n 5u 10u) DC 1.2 AC -0.5m
x1 inp inn outp GND outn bias_p_casc bias_p_src bias_n_casc v_feedback vdd ota_folded_cascoded
VDD vdd GND {Vdd}
V_pbias_src bias_p_src GND {vbias_p_src}
V_pbias_casc bias_p_casc GND {vbias_p_casc}
V_nbias_casc bias_n_casc GND {vbias_n_casc}
V_biasn_sink bias_n_sink GND {vbias_n_sink}
x2 outp v_feedback outn vcm_ref GND ideal_cmfb
C2 outn GND {Cl2} m=1
C1 outp GND {Cl1} m=1
R1 v_feedback bias_n_sink {Riso} m=1
**** begin user architecture code


.param temp=27
.control
option sparse
save all
op
write ota_folded_cascoded_tb.raw
set appendwrite
tran 1n 10u
ac dec 100 1 1G
write ota_folded_cascoded_tb.raw

* ---- AC plots ----
setplot ac1
plot db((v(outp)-v(outn))/(v(inp)-v(inn)))
plot phase((v(outp)-v(outn))/(v(inp)-v(inn)))

* ---- Transient plots ----
setplot tran1
plot v(inp) v(inn)
plot v(outp) v(outn)
plot v(outp)-v(outn)
plot (v(outp)+v(outn))/2
.endc



.lib cornerMOShv.lib mos_tt



.param Vdd=3
.param Vcm=Vdd/2
.param vbias_n_sink=0.7
.param vbias_n_casc=1.2
.param vbias_p_src=2.3
.param vbias_p_casc=1.8
.param Riso=100k
.param Cl1=3p Cl2=3p
.param Gcmfb=5m


 .include [file rootname [xschem get schname]].save

**** end user architecture code
**.ends

* expanding   symbol:  ota_folded_cascoded.sym # of pins=12
** sym_path: 3_real_circuits/ota_folded_cascoded.sym
** sch_path: 3_real_circuits/ota_folded_cascoded.sch
.subckt ota_folded_cascoded inp inn outp vss outn vbias_p_casc vbias_p_src vbias_n_casc vbias_n_sink
+ vdd
*.ipin inp
*.ipin inn
*.iopin vss
*.ipin vdd
*.opin outn
*.opin outp
*.ipin vbias_n_casc
*.ipin vbias_p_casc
*.ipin vbias_p_src
*.ipin vbias_n_sink
XM1 net5 inp net1 vss sg13_hv_nmos w=2u l=1u ng=1 m=1 mm_ok=1
XM10 net5 vbias_p_src vdd vdd sg13_hv_pmos w=8u l=1u ng=1 m=1 mm_ok=1
XM8 outn vbias_p_casc net5 vdd sg13_hv_pmos w=4u l=1u ng=1 m=1 mm_ok=1
XM11 net4 vbias_p_src vdd vdd sg13_hv_pmos w=8u l=1u ng=1 m=1 mm_ok=1
XM9 outp vbias_p_casc net4 vdd sg13_hv_pmos w=4u l=1u ng=1 m=1 mm_ok=1
XM7 outp vbias_n_casc net3 vss sg13_hv_nmos w=1u l=1u ng=1 m=1 mm_ok=1
XM5 net3 vbias_n_sink vss vss sg13_hv_nmos w=1u l=1u ng=1 m=1 mm_ok=1
XM4 net2 vbias_n_sink vss vss sg13_hv_nmos w=1u l=1u ng=1 m=1 mm_ok=1
XM6 outn vbias_n_casc net2 vss sg13_hv_nmos w=1u l=1u ng=1 m=1 mm_ok=1
XM2 net4 inn net1 vss sg13_hv_nmos w=2u l=1u ng=1 m=1 mm_ok=1
XM3 net1 vbias_n_sink vss vss sg13_hv_nmos w=2.5u l=1.5u ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  ideal_cmfb.sym # of pins=5
** sym_path: 3_real_circuits/ideal_cmfb.sym
** sch_path: 3_real_circuits/ideal_cmfb.sch
.subckt ideal_cmfb vop vctrl von vcm_ref vss
*.opin vctrl
*.ipin vop
*.ipin von
*.ipin vcm_ref
*.iopin vss
B1 voc vss V = (V(vop)+V(von))/2
B2 verr vss V = V(vcm_ref) - V(voc)
B3 vctrl vss I = {Gcmfb}*V(verr)
* noconn vop
* noconn von
* noconn vcm_ref
.ends

.GLOBAL GND
.end
