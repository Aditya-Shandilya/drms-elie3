** sch_path: 3_real_circuits/comparator_latched_tb.sch
**.subckt comparator_latched_tb
x1 vdd inp inn phi2 outp outn phi2_b GND comparator_latched
VDD vdd GND {Vdd}
VinP inp GND PULSE({Vcm+Vdiff/2} {Vcm-Vdiff/2} 5u 1n 1n 5u 10u) DC {Vcm+Vdiff/2}
VinN inn GND PULSE({Vcm-Vdiff/2} {Vcm+Vdiff/2} 5u 1n 1n 5u 10u) DC {Vcm-Vdiff/2}
Vphi2 phi2 GND PULSE(0 {Vdd} 0n 1n 1n 490n 1000n)
Vphi2_b phi2_b GND PULSE(0 {Vdd} 495n 1n 1n 490n 1000n)
**** begin user architecture code


.option temp=27
.option savecurrents
.control
option sparse
save all
op
write comparator_latched_tb.raw
tran 1n 12u
plot v(phi2) v(phi2_b)
plot v(inp) v(inn)
plot v(outp) v(outn)
.endc



.lib cornerMOShv.lib mos_tt



.param Vdd=3
.param Vcm=Vdd/2
.param Vdiff=10m


 .include [file rootname [xschem get schname]].save

**** end user architecture code
**.ends

* expanding   symbol:  comparator_latched.sym # of pins=8
** sym_path: 3_real_circuits/comparator_latched.sym
** sch_path: 3_real_circuits/comparator_latched.sch
.subckt comparator_latched vdd inp inn phi2 outp outn phi2_b vss
*.ipin inp
*.ipin vdd
*.ipin inn
*.opin outp
*.opin outn
*.ipin phi2_b
*.ipin phi2
*.iopin vss
XM9 outn phi2 vss vss sg13_hv_nmos w=0.3u l=0.45u ng=1 m=1 mm_ok=1
XM7 outn outp vss vss sg13_hv_nmos w=2u l=0.45u ng=1 m=1 mm_ok=1
XM8 outp outn vss vss sg13_hv_nmos w=2u l=0.45u ng=1 m=1 mm_ok=1
XM10 outp phi2 vss vss sg13_hv_nmos w=0.3u l=0.45u ng=1 m=1 mm_ok=1
XM5 net2 phi2_b outn vss sg13_hv_nmos w=2u l=0.45u ng=1 m=1 mm_ok=1
XM6 net1 phi2_b outp vss sg13_hv_nmos w=2u l=0.45u ng=1 m=1 mm_ok=1
XM1 net2 inp vdd vdd sg13_hv_pmos w=7u l=1u ng=1 m=1 mm_ok=1
XM3 net2 net1 vdd vdd sg13_hv_pmos w=0.3u l=0.4u ng=1 m=1 mm_ok=1
XM4 net1 net2 vdd vdd sg13_hv_pmos w=0.3u l=0.4u ng=1 m=1 mm_ok=1
XM2 net1 inn vdd vdd sg13_hv_pmos w=7u l=1u ng=1 m=1 mm_ok=1
.ends

.GLOBAL GND
.end
